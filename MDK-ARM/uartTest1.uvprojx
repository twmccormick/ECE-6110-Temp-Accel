# Keil uVision project uartTest1.uvprojx, settings and files
target uartTest1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32L475VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: uartTest1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L475xx
  c include: ../Core/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;..\Drivers\B-L475E-IOT01;..\Drivers\Components\Common;..\Drivers\Components\hts221;..\Drivers\Components\lps22hb;..\Drivers\Components\lis3mdl;..\Drivers\Components\lsm6dsl
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Drivers/B-L475E-IOT01
    ../Drivers/B-L475E-IOT01/: stm32l475e_iot01.c stm32l475e_iot01_tsensor.c stm32l475e_iot01_hsensor.c stm32l475e_iot01_gyro.c stm32l475e_iot01_magneto.c stm32l475e_iot01_accelero.c stm32l475e_iot01_psensor.c
  group Application/MDK-ARM
    ./: startup_stm32l475xx.s
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group Application/User/Core
    ../Core/Src/: main.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/Components
    ../Drivers/Components/lis3mdl/: lis3mdl.c
    ../Drivers/Components/lps22hb/: lps22hb.c
    ../Drivers/Components/hts221/: hts221.c
    ../Drivers/Components/lsm6dsl/: lsm6dsl.c
software components: CMSIS:CORE 4.3.0
